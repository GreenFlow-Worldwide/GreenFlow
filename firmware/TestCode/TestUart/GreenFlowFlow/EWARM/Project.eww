<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\GreenFlowFlow.ewp</path>
  </project>
  <batchBuild />
</workspace>
